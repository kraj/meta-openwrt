# This file Copyright (C) 2018 Daniel Dickinson <cshored@thecshore.com>
#
# It is released under the MIT license.  See COPYING.MIT
# for the terms.

VIRTUAL-RUNTIME_dev_manager ?= "procd"
VIRTUAL-RUNTIME_login_manager ?= "busybox"
VIRTUAL-RUNTIME_init_manager ?= "procd"
VIRTUAL-RUNTIME_kmod_manager ?= "ubox"
VIRTUAL-RUNTIME_syslog ?= "ubox"
VIRTUAL-RUNTIME_base-utils ?= "busybox"
VIRTUAL-RUNTIME_network_manager ?= "netifd"
